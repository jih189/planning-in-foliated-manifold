Commit message: clean the code

File: fetch_ros/fetch_description/robots/fetch.urdf (robot description, URDF)
Before this commit: robot fetch, 26 links, 25 joints
Links:
- link base_link: mass 70.1294 -> None
